<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Module gps_neo_m8l.ewp</path>
  </project>
  <batchBuild />
</workspace>
